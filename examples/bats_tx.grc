<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bats_tx</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_sym</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2485000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>value</key><value>52001</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(1,0)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>interp</key><value>chips_per_sym</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>30</value></param>
<param><key>min</key><value>1</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>enc out</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>ip</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq-1e6, 1e6)</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
<param><key>excess_bw</key><value>0.5</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>to USRP</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>bats_psk31_encoder</key>
<param><key>id</key><value>bats_psk31_encoder_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("aaaa\n")</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>port</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>bats_simple_mac</key>
<param><key>id</key><value>bats_simple_mac_0</value></param>
<param><key>cycle_dur</key><value>1</value></param>
<param><key>data_slot_dur</key><value>1.25e-3</value></param>
<param><key>location_slot_dur</key><value>250e-6</value></param>
<param><key>bandwidth</key><value>200000</value></param>
<param><key>chips_per_sym</key><value>chips_per_sym</value></param>
</block>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>blocks_char_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bats_psk31_encoder_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bats_simple_mac_0</source_block_id><sink_block_id>bats_psk31_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>bats_simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
